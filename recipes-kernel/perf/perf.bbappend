PERF_SRC_append_powerpc = "arch/powerpc/include"
PERF_SRC_append_powerpc64 = "arch/powerpc/include"
PERF_SRC_append_x86 = "arch/x86/lib"
PERF_SRC_append_x86-64 = "arch/x86/lib"
