FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://yylex-Explicilty-cast-fprintf-to-void.patch"
